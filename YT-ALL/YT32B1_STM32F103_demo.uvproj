# Keil uVision project YT32B1_STM32F103_demo.uvproj, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCCv506u7)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: YT32B1_STM32F103_demo +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\Lib\inc;.\Lib\src;.\User;.\Startup;.\Basic\delay;.\Basic\sys;.\Hardware\LED;.\Basic\rtc;.\Hardware\BUZZER;.\Basic\i2c;.\Hardware\OLED0561;.\Basic\font;.\Hardware\LM75A;.\Basic\adc;.\Basic\rcc;.\Basic\usart;.\Hardware\TOUCH_KEY;.\Hardware\RELAY;.\Hardware\STEP_MOTOR;.\Hardware\KEY;.\Hardware\ENCODER;.\Basic\spi;.\Hardware\CH376;.\Hardware\MY1690;.\Hardware\TM1640;.\Hardware\CAN;.\Hardware\RS485
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_can.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group User
    ./User/: main.c stm32f10x_it.c
  group Basic
    ./Basic/delay/: delay.c
    ./Basic/sys/: sys.c
    ./Basic/rtc/: rtc.c
    ./Basic/i2c/: i2c.c
    ./Basic/adc/: adc.c
    ./Basic/rcc/: rcc.c
    ./Basic/usart/: usart.c
    ./Basic/spi/: spi.c
  group Hardware
    ./Hardware/LED/: led.c
    ./Hardware/KEY/: key.c
    ./Hardware/BUZZER/: buzzer.c
    ./Hardware/OLED0561/: oled0561.c
    ./Hardware/LM75A/: lm75a.c
    ./Hardware/STEP_MOTOR/: step_motor.c
    ./Hardware/RELAY/: relay.c
    ./Hardware/TOUCH_KEY/: touch_key.c
    ./Hardware/ENCODER/: encoder.c
    ./Hardware/CH376/: ch376.c filesys.c
    ./Hardware/MY1690/: MY1690.c
    ./Hardware/TM1640/: TM1640.c
    ./Hardware/CAN/: can.c
    ./Hardware/RS485/: rs485.c
