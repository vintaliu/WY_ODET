# Keil uVision project X2445DK-与自动电量识别配套(MC51F003A4).uvproj, settings and files
target X2445DK-与自动电量识别配套(MC51F003A4) (MCS-51)
  device: MC51F003A4 SinoMCU
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0 - 0xFF) CLOCK(16000000)
  output: X2445DK-(MC51F003A4) +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Include
  link misc: REMOVEUNUSED
  group STARTUP
    ../STARTUP/: STARTUP.A51
  group USER
    ../Code/: main.c
  group Common
    ../Code/: 51_interrupt.c function.c SystemInit.c Uart.c
  group ProInfo
    ../Code/: SerialOrder.txt
