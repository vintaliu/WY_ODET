# Keil uVision project X2445DK-PT32F005.uvprojx, settings and files
target X2445DK-PT32F005 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PT32F005F6X6 PengpaiMicroelectronics
  pack: PAI-IC.PT32X005_DFP.1.0.2
  cpu: IRAM(0x20000000,0x0800) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: X2445DK-PT32F005 +hex
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,PT32X005,USE_FULL_ASSERT
  c include: ..\PT32X005_FWLib\inc;..\FileSources
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x800
  group System
    ../FileSources/: startup_PT32X005x.s
  group User
    ../FileSources/: main.c system_PT32X005.c PT32X005_it.c X2445DK_Eeprom_P32.c X2445DK_Function_PTC32.c X2445DK_Init_P32.c X2445DK_Uart_P32.c printfWindow.c
  group PT32L03x_FWLib
    ../PT32X005_FWLib/src/: PT32X005_gpio.c PT32X005_sys.c PT32X005_uart.c PT32X005_adc.c PT32X005_flash.c PT32X005_pwm.c PT32X005_misc.c
  group Retarget
    ../Retarget/: PT32X005_retarget.c PT32X005_serial.c
software components: CMSIS:CORE 5.1.2
