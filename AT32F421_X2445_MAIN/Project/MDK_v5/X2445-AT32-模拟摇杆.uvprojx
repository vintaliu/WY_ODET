# Keil uVision project X2445-AT32-模拟摇杆.uvprojx, settings and files
target X2445-AT32F421-模拟摇杆 (5060960::V5.06 update 7 (build 960)::.\ARMCCv506u7)
  device: -AT32F421C8T7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.8
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: X2445-AT32F421-模拟摇杆 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F421C8T7,USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\..\User;..\..\User\Bsp;..\..\User\Bsp\inc;..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ../../User/: DriverUart.c DriverInit.c DriverControl.c DriverMain.c ControlUsedArry.c Mlx90393.c
  group BSP
    ../../User/Bsp/: DriveBsp.c
    ../../User/: at32f4xx_it.c
    ../../User/Bsp/src/: DriveDelay.c
  group CMSIS
    ../../User/: system_at32f4xx.c
  group Libraries
    ../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f421c8t7.s
    ../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_dbgmcu.c at32f4xx_gpio_ex.c at32f4xx_rcc.c misc.c at32f4xx_adc.c at32f4xx_pwr.c at32f4xx_exti.c at32f4xx_dma.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_syscfg.c at32f4xx_wwdg.c at32f4xx_iwdg.c
